# Keil uVision project GD32E230F8_Project.uvprojx, settings and files
target GD32E23x (6220000::V6.22::ARMCLANG)
  device: GD32E230F8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\libraries\GD32E23x_standard_peripheral\Include;..\..\libraries\GD32E23x_standard_peripheral\Source;..\..\app;..\..\bsp;..\..\drivers;..\..\user;..\..\libraries\CMSIS\GD\GD32E23x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../../user/: gd32e23x_it.c main.c
  group CMSIS
    ../../libraries/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../libraries/GD32E23x_standard_peripheral/Source/: gd32e23x_rcu.c gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_syscfg.c gd32e23x_exti.c gd32e23x_usart.c
  group Startup
    ../../libraries/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group BSP
    ../../bsp/: bsp_led.c delay.c
software components: CMSIS:CORE 6.1.0
